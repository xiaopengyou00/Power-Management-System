# Keil uVision project STM32.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\USER;..\STM32F10x_FWLib\inc;..\BASIC\DELAY;..\BASIC\SYS;..\BASIC\USART;..\BASIC\TIMER;..\BASIC\ADC;..\HARDWARE\ESP8266;..\HARDWARE\NET_USART;..\HARDWARE\BEEP;..\HARDWARE\LED;..\HARDWARE\RELAY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/NET_Usart/: net_usart.c
    ../HARDWARE/BEEP/: beef.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RELAY/: relay.c
  group BASIC
    ../BASIC/delay/: delay.c
    ../BASIC/sys/: sys.c
    ../BASIC/TIMER/: timer.c
    ../BASIC/ADC/: adc.c
    ../BASIC/USART/: usart.c
  group CMSIS
    ./: system_stm32f10x.c
    ../CMSIS/: core_cm3.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_dma.c
  group STARTUP
    ../CMSIS/: startup_stm32f10x_md.s
